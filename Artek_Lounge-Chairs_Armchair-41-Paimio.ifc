Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-09-25T21:14:19
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Sep 25 21:14:19 2022 * Host: DESKTOP-4UM54TC * Database: C:\Users\Vlad\AppData\Local\Temp\{8EA99CD9-3D85-4F43-B929-82861C93DB56}\ifc * Database version: 5507 * Database creation date: Sun Sep 25 21:14:18 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Sep 25 21:14:18 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Sep 25 21:14:18 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFurnishingElement: Armchair 41 Paimio, Artek_Lounge-Chairs_Armchair-41-Paimio:Armchair 41 Paimio:298609
In: Level 1
Type - Material: Natural Birch, lacquered, White, laminate
Type - General - Author: BIMStone; BIMObjectName: Artek_Lounge-Chairs_Armchair-41-Paimio; ManufacturerName: Artek; ManufacturerURL: https://www.artek.fi/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: Combining a traditional outline with a light, organic form, this revolutionary interpretation of the club chair set new standards in modern furniture design.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Dining chairs; Uniclass2015Reference: Pr_40_50_12_22; Version: 1; VersionDate: 23/09/2022
Type - Identity Data - Cost: 0; Description: Combining a traditional outline with a light, organic form, this revolutionary interpretation of the club chair set new standards in modern furniture design.; Designer: Alvar Aalto; Manufacturer: Artek; Model: Armchair 41 Paimio; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.artek.fi/downloads/Armchair-41-Paimio-Factsheet-1848213.pdf; Type Name: Armchair 41 Paimio; URL: https://www.artek.fi/en/products/armchair-41-paimio
Type - Materials and Finishes - ChairMainMaterial: Natural Birch, lacquered
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Artek; CodePerformance: n/a; Color: Wooden; Constituents: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: Artek_Lounge-Chairs_Armchair-41-Paimio; Features: n/a; Finish: n/a; Grade: n/a; Material: Wood; ModelNumber: n/a; ModelReference: n/a; Name: Armchair-41-Paimio; ReplacementCost: n/a; Shape: Sculptured; Size: 800x600x640 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.45834 m2; Volume: 0.334519 m3
Materials and Finishes - ChairSeatMaterial: White, laminate
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Artek_Lounge-Chairs_Armchair-41-Paimio: Armchair 41 Paimio; Family and Type: Artek_Lounge-Chairs_Armchair-41-Paimio: Armchair 41 Paimio; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Artek_Lounge-Chairs_Armchair-41-Paimio: Armchair 41 Paimio; Type Id: Artek_Lounge-Chairs_Armchair-41-Paimio: Armchair 41 Paimio; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
